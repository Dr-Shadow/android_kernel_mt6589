## drivers/opponetworkpmsmodule/Kconfig
```kconfig
#
#permission intercept
#

config PERMISSION_INTERCEPT
	bool "permission intercept"
	default y
	help
	  This is permission intercept module.
```
